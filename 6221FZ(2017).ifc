Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-05-13T16:24:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 13 16:24:33 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{9B7B0AC2-C10E-4C85-BACC-8DDEECC2F099}\ifc * Database version: 5507 * Database creation date: Mon May 13 16:24:33 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 13 16:24:33 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 13 16:24:33 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth, 6221FZ:6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth:377953
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 112 mm
Type - Electrical Engineering(Type) - Operating Voltage: 12 V
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 9 / 12 VDC; Electronic Parts: Low battery indication
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6221FZ; ConvergoRefNr: 0087-1905-0014-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 08/04/2018
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150085888; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110226; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200203; Protection Class: IP 55; VVS Number: 704270804
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/6221FZ; Class: Touchless, low pressure, Bluetooth®; Dimension Drawing URL: http://static.oras.com/dimdrw/6221FZ; FDV Document URL: http://www.oras.com/datasheet/6221FZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6221FZ; Group: Washbasin faucets; Long Marketing: Low pressure model. Touchless washbasin faucet with a temperature adjustment handle. The faucet can be taken out of operation, e.g. for cleaning the basin, by placing a cleaning cover over the sensor. The faucet is equipped with litter filters, non-return valves and flexible pipes. No adjustments need to be made at installation because an advanced Autofocus sensor is used. Bluetooth connection enables easy monitoring and adjustments of the faucet. Electrical connection 9 V or 12 V via a separate power supply (e.g. Oras No. 199275).; Manufacturer: Oras; Market: INT;FIN;NOR;POL;RUS;EST;LTU;LVA;UKR; Model: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; Name_en: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 370 x 192 x 90; Package Weight: 2.1 kg; Product Code: 6221FZ; Product Datasheet: http://www.oras.com/datasheet/6221FZ/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6221FZ; Product URL: http://static.oras.com/6221FZ; Type Name: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; Usage Group: Offices, personnel sanitary facilities;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Kindergartens;Institutional kitchens;Hospitals;Food industry;Gas stations;Schools;Households;Airports, Railway stations;Sports stadiums;Hotels, Restaurants, Café
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation, adjustable settings (via bluetooth); Aerator: Burglarproof; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.oras.com/manual/6221FZ; Installation Type: Deck mounted; Intelligent After Flow Period: ON (OFF/ON); Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Recognition Range: optimally preset; Spare Parts: http://static.oras.com/sp/6221FZ; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6221FZ; Features: Touchless, low pressure, Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6221FZ; Name: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 70x165x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6221FZ; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0522117 m2; Volume: 0.00197128 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6221FZ: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; Family and Type: 6221FZ: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6221FZ: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; Type Id: 6221FZ: 6221FZ Washbasin faucet, low pressure, 12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
